# Keil uVision project EthernetOneWireThermometer.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EthernetOneWireThermometer +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS;.\User;.\User\core\inc;.\User\ENC28J60\Hardware\inc;.\User\ENC28J60\Middleware\inc;.\User\ENC28J60\Interaface\inc;.\User\arch;.\User\lwip\inc;.\User\lwip\inc\lwip
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: startup_stm32f10x_xl.s system_stm32f10x.c
  group CORE
    ./User/core/src/: main.c rcc.c
  group ENC28J60
    ./User/ENC28J60/Interaface/src/: enc28j60.c
    ./User/ENC28J60/Middleware/src/: enc28j60_middleware.c
    ./User/ENC28J60/Hardware/src/: enc28j60_hardware.c
  group lwip
    ./User/lwip/src/core/: def.c init.c mem.c memp.c netif.c pbuf.c inet_chksum.c ip.c timeouts.c
    ./User/lwip/src/core/ipv4/: etharp.c icmp.c ip4.c ip4_addr.c ip4_frag.c
    ./User/lwip/src/core/netif/: ethernet.c
  group arch
    ./User/arch/: sys_arch.c
